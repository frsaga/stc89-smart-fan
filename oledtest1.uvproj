# Keil uVision project oledtest1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: oledtest1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 delay.c delay.h fan.c fan.h i2c.c i2c.h main.c oled.c oled.h sensors.c sensors.h timer2_ctrl.c timer2_ctrl.h key.c key.h
